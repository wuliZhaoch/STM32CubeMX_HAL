<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\04_NUCLEO-F767ZI.ewp</path>
  </project>
  <batchBuild />
</workspace>
